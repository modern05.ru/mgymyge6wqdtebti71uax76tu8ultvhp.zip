Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2022-05-04T10:53:34
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Alternate UI 19.2.30.41
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Wed May 04 10:53:34 2022* Host: NCL-PI02* Database: C:\Users\connm\AppData\Local\Temp\{1F868DA2-1BCA-4BCA-8B0A-647FF9779F81}\ifc* Database version: 5507* Database creation date: Wed May 04 10:53:34 2022* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Wed May 04 10:53:34 2022* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Wed May 04 10:53:34 2022* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcFlowTerminal: EmbracePlusHandShowerTVS10841401, NBS_VilleroyAndBochAG_ShwrHds_Embrace_PLUS_HandShower_TVS10841401:EmbracePlusHandShowerTVS10841401:88646
In: Level 1
Type - PredefinedType: SHOWER; Classification: Pr_40_20_87_76 (Uniclass2015); Material: NBS_VilleroyAndBochAG_Chrome, NBS_VilleroyAndBochAG_Nozzle
Type - BOS_General - Author: NBS; BIMObjectName: NBS_VilleroyAndBochAG_ShowerHeads_Embrace_Plus_HandShower_TVS10841401; ManufacturerName: Villeroy & Boch AG; ManufacturerURL: https://pro.villeroy-boch.com; NBSCertification: www.nationalbimlibrary.com/cert/1fxvhiuu; ProductInformation: n/a; Uniclass2015Title: Shower heads; Uniclass2015Code: Pr_40_20_87_76; Uniclass2015Version: Products v1.22; Version: 3
Type - NBS_Data - Approval: n/a; ContainsRedListMaterials: n/a; CountryOfMaterialOrigin: n/a; CountryOfProductManufacture: n/a; EmbodiedCarbon: n/a; FlowRateMaximum: 5.05 L/min; Form: Single function fixed head; IntegralAccessories: n/a; MaterialsBody: Brass; MaterialsFinishAndColour: Chrome.,Brushed Nickel Matt.,English Gold.,Brushed Gold.,Matt Black; Recyclability: n/a; RecycledContent: n/a; Size: n/a; Standards: n/a
Type - IFC - IfcExportAs: IfcSanitaryTerminalType; IfcExportType: SHOWER
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_40_20_87_76:Shower heads; CodePerformance: n/a; Color: Silver,Black,Gold; Constituents: n/a; Description: n/a; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Gloss,Matt; Grade: n/a; Manufacturer: n/a; Material: Brass; ModelNumber: n/a; ModelReference: Embrace Plus Hand Shower TVS10841401; Name: ShowerHeads_Embrace_Plus_HandShower_TVS10841401_VilleroyAndBochAG; NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; ReplacementCost: n/a; Shape: n/a; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
COBie - AssetIdentifier: n/a; Barcode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
